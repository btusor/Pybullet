Commit message: Collision+impedance

File: meshes/CS612.urdf (robot description, URDF)
Before this commit: robot CS612urdf, 8 links, 7 joints
Links:
- link base_link: geometry visual mesh filename=base_link.STL
